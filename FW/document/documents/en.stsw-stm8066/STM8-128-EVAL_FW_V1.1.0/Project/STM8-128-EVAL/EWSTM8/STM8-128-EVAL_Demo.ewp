# IAR project STM8-128-EVAL_Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208MB STM8S208MB
  General.GenCodeModel: 2
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S208; USE_STM8_128_EVAL
  ICCSTM8.CCIncludePath2: ..; ..\inc; ..\..\..\libraries\stm8s_stdperiph_driver\inc; ..\..\..\utilities\stm8s_eval; ..\..\..\utilities\stm8s_eval\common; ..\..\..\..\utilities\stm8s_eval\stm8-128_eval
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: yyy.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Source Files
    ../src/: buzzer.c demo_about.c demo_adc.c demo_beeper.c demo_games.c demo_help.c demo_microsd.c demo_pwm.c demo_system.c demo_timer.c functions.c joystick_button.c main.c menu.c stm8s_it.c
  group STM8S_EVAL
    ../../../Utilities/STM8S_EVAL/: stm8s_eval.c
    ../../../Utilities/STM8S_EVAL/Common/: stm8s_eval_lcd.c stm8s_eval_spi_sd.c
  group STM8S_StdPeriph_Drivers
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart1.c stm8s_uart3.c stm8s_wwdg.c
